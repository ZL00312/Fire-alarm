# Keil uVision project 实验二.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 实验二 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Source Group 1
    ./: STARTUP.A51
    ./Src/: main.c ADC0809.c BH1750FVI.c delay.c DS18B20.c time.c uart.c
  group LINK
    ./Include/: ADC0809.h BH1750FVI.h delay.h DS18B20.h time.h uart.h
